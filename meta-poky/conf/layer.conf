## meta-poky/conf/layer.conf
```bitbake
LAYERNAME = "meta-yocto-poky"
LAYERVERSION = "3"
LAYERSERIES_COMPAT = "garburn"
LAYERDEPENDS = "oe-core"
```
